## boards/shields/levels54/Kconfig.shield
```kconfig
config SHIELD_Levels54_DONGLE
    def_bool $(shields_list_contains,levels54_dongle)
```
